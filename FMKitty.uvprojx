# Keil uVision project FMKitty.uvprojx, settings and files
target FMKitty (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32L152C8xxA STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.4.1
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: FMKitty +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_FULL_LL_DRIVER,USE_HAL_DRIVER,STM32L152xBA
  c include: ../../../Core/Inc;../../../Drivers/STM32L1xx_HAL_Driver/Inc;../../../Drivers/STM32L1xx_HAL_Driver/Inc/Legacy;../../../Drivers/CMSIS/Device/ST/STM32L1xx/Include;../../../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32l152xba.s
  group Application/User/Core
    ../../../Core/Src/: main.c gpio.c adc.c dac.c i2c.c lcd.c rtc.c tim.c usart.c stm32l1xx_it.c stm32l1xx_hal_msp.c
  group Drivers/STM32L1xx_HAL_Driver
    ../../../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_ll_rcc.c stm32l1xx_ll_utils.c stm32l1xx_ll_exti.c stm32l1xx_ll_gpio.c stm32l1xx_ll_adc.c stm32l1xx_ll_dma.c stm32l1xx_hal.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_flash.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal_gpio.c stm32l1xx_hal_dma.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_cortex.c stm32l1xx_hal_exti.c stm32l1xx_ll_dac.c stm32l1xx_ll_i2c.c stm32l1xx_hal_lcd.c stm32l1xx_ll_rtc.c stm32l1xx_hal_tim.c stm32l1xx_hal_tim_ex.c stm32l1xx_ll_tim.c stm32l1xx_ll_usart.c
  group Drivers/CMSIS
    ../../../Core/Src/: system_stm32l1xx.c
software components: CMSIS:CORE 4.3.0
